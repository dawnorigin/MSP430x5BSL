# IAR project bootloader.ewp, settings and files
configuration MSP430F5529 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSPEXP430F5529LP__
  ICC430.newCCIncludePaths: ../../Source/Command_Interpreter/; ../../Source/API/; ../../Source/Peripheral_Interfaces/; ../../Source/Application/; ../../Source/Peripheral_Interfaces/USCIA_UART/
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: CONFIG\lnk430_BSL_AREA_RAM_2400-33FF.xcl
  XLINK.XlinkStackSize: 1
configuration MSP430F5529Debug (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: __DEBUG__
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
configuration MSP430F5438A (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  XLINK.XclFile: CONFIG\lnk430_BSL_AREA_RAM_1C00-5BFF.xcl
configuration MSP430F5438ADebug (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  ICC430.CCDefines: __DEBUG__
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  group (top)
    ../../Source/API/: BSL430_API.c
    ../../Source/Command_Interpreter/: BSL430_Command_Interpreter.c
    ../../Source/Application/: BSL430_Low_Level_Init.s43
    ../../Source/Peripheral_Interfaces/USCIA_UART/: BSL430_PI_USCIA.c
    CONFIG/: lnk430_BSL_AREA_RAM_1C00-5BFF.xcl lnk430_BSL_AREA_RAM_2400-33FF.xcl
